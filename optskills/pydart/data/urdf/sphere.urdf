Commit message: The initial kicking motion

File: optskills/pydart/data/urdf/sphere.urdf (robot description, URDF)
Before this commit: robot Sphere, 1 links, 0 joints
Links:
- link ball: mass 0.323808555028714 -> 0.05
